# Keil uVision project Pup.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pup +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=3
  c include: ..\code\drivers\MDR32F9Qx;..\code\paralax;..\code\;..\code\drivers
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ../code/: main.c MDR32F9Qx_it.c paralaks.c check_sum.c
  group paralax
    ../code/paralax/: ParalaxCalc_fixpt.c
  group Drivers
    ../code/drivers/: dac.c gpio.c rcc.c timer.c uart.c
  group MDR32F9Qx
    ../code/drivers/MDR32F9Qx/: MDR32F9Qx_dac.c MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c
software components: CMSIS:CORE 5.6.0, Device:Startup_MDR1986BE9x 1.3.1
